# Keil uVision project stm程序.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm程序 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\FWlib\inc;.\user;.\Public;.\App\exti;.\App\key;.\App\led;.\App\time;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\UCOS-BSP;.\UCOSIII\UCOS-CONFIG;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./Public/: system.c
    ./user/: main.c
  group core
    ./user/: system_stm32f10x.c
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./user/: stm32f10x_it.c
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c
  group App
    ./App/led/: led.c
    ./App/time/: time.c
  group UCOSIII-BSP
    ./UCOSIII/UCOS-BSP/: bsp.c
  group UCOSIII-CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII-LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII-CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII-PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII-CONFIG
    ./UCOSIII/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
