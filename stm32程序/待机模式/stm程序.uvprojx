# Keil uVision project stm程序.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm程序 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\FWlib\inc;.\user;.\Public;.\App\exti;.\App\key;.\App\led;.\App\time;.\App\pwm;.\App\iwdg;.\App\wwdg;.\App\input;.\App\wkup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c
  group core
    ./user/: system_stm32f10x.c
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./user/: stm32f10x_it.c
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c
  group App
    ./App/led/: led.c
    ./App/key/: key.c
    ./App/input/: input.c
    ./Public/: usart.c
    ./App/wkup/: wkup.c
  group Public
    ./Public/: system.c
